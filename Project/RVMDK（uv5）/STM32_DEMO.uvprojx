# Keil uVision project STM32_DEMO.uvprojx, settings and files
target STM32_DEMO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207VGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_DEMO +hex
  AfterMake: fromelf.exe --bin -o ..\..\Output\BootLoader_F207.bin ..\..\Output\STM32_DEMO.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F2XX, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\Libraries\FWlib\inc;..\..\USER;..\..\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f2xx.s
  group USER
    ../../USER/: main.c stm32f2xx_it.c USER_SYSTick.c stm32f2xx_conf.h CRC_X25.c CommandProcess.c
  group FWlib
    ../../Libraries/FWlib/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c system_stm32f2xx.c
  group HARDWARE
    ../../HARDWARE/: HARD_NVIC.c HARD_USART.c HARD_FLASH.c
  group Doc
    ../../Doc/: ReadMe.txt
